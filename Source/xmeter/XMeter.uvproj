# Keil uVision project XMeter.uvproj, settings and files
target Release (MCS-51)
  device: STC89C516RD+ Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xFFFF) CLOCK(45000000) MODP2
  output: XMeter +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: __OSCILLATO_6T__
  c include: ..\protocol;.\state_machine;.\console
  group main
    ./: STARTUP.A51 main.c i2c.c debug.c com.c rom.c clock.c task.c sm.c button.c delay.c beeper.c lcd.c xmeter.c gpio.c control.c console.c
    ../protocol/: protocol.c
  group state machine
    ./state_machine/: sm_xmeter.c sm_set_param.c
  group console
    ./console/: con_calibrate_current.c con_calibrate_temperature.c con_calibrate_voltage_diss.c con_calibrate_voltage_out.c con_common.c
target Debug (MCS-51)
  device: STC89C516RD+ Series STC
  cpu: as above
  output: XMeter_Debug +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: __OSCILLATO_6T__,__XMETER_DEBUG__
  c include: ..\protocol;.\state_machine;.\console
